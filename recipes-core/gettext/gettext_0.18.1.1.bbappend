
EXTRA_OECONF += "LIBS=-lpthread"


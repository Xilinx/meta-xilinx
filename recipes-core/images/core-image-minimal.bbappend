
include rootfs-extra.inc
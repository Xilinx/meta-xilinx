COMPATIBLE_MACHINE:versal = "versal"
COMPATIBLE_MACHINE:versal-2vp = "versal-2vp"
COMPATIBLE_MACHINE:versal-2ve-2vm = "versal-2ve-2vm"

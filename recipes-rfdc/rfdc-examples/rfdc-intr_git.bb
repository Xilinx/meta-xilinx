SUMMARY = "Simple rfdc-intr application"

require rfdc-examples.inc

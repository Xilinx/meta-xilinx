SUMMARY = "Simple rfdc-read-write application"

require rfdc-examples.inc

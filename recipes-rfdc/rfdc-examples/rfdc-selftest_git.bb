SUMMARY = "Simple rfdc-selftest application"

require rfdc-examples.inc

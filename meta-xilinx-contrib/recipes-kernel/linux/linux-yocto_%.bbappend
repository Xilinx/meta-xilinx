# MicroBlaze KMACHINEs
KMACHINE:ml605-qemu-microblazeel = "qemumicroblazeel"


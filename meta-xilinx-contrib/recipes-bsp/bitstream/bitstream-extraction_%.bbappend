COMPATIBLE_MACHINE:zybo-linux-bd-zynq7 = "^$"


QEMU_TARGETS += "microblazeel"

FILESEXTRAPATHS_append := "${THISDIR}/files:"
#SRC_URI_append += " \
#		file://microblaze-Add-support-for-loading-initrd-images.patch \
#		file://HACK_target-arm_Harcode_the_SCU_offset.patch \
#		file://HACK_zynq_slcr_Bring_SLCR_out_of_reset_in_kernel_state.patch \
#		"

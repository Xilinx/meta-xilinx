
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += " \
		file://8fa2346723fb74e8220ac9f186dabc2f57e4cb43.patch \
		file://dma-xlnx-zynq-devcfg.patch \
		"


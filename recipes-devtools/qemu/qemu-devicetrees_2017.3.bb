include qemu-devicetrees.inc

XILINX_RELEASE_VERSION = "v2017.3"
SRCREV ?= "7b167f0515a2ffee2bdb594bb79cb1e5cdb64f89"

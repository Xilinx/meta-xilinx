include qemu-xilinx.inc

XILINX_QEMU_VERSION = "v2.8.1"
XILINX_RELEASE_VERSION = "v2017.3"
SRCREV ?= "45e09ad7692a2a5ed83f584610fe7c9ed3f75c3f"

PACKAGECONFIG:append = " gui"

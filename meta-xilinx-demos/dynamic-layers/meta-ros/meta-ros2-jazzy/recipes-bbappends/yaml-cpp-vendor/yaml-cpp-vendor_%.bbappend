INSANE_SKIP:${PN} += "dev-so"

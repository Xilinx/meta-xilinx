SRC_URI:remove = "file://0001-CMakeLists.txt-fetch-orocos-kdl-with-bitbake-fetcher.patch"
SRCREV_release:forcevariable = "adca6201616af928533d70faea6042fe0239e898"

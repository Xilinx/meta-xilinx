SRC_URI:remove = "file://0001-CMakeLists.txt-drop-dependency-on-zstd_vendor.patch"
SRCREV = "3f3c01609c3bef74cfc3f3229b0d57964c6bd465"

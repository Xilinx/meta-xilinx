inherit python_setuptools_build_meta

RDEPENDS:${PN} += "python3-flake8 python3-pydocstyle"

MULTIMEDIA_PACKAGES:append = " packagegroup-xilinx-qt"

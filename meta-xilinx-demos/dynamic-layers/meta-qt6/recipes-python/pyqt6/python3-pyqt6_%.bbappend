PYQT_MODULES += "QtSvg"

DEPENDS += "qtsvg"

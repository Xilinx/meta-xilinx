# See include file for common information
include linux-xlnx.inc

# Kernel version and SRCREV correspond to:
#   github.com/Xilinx v14.4 tag
# If required for a custom layer:
#   Override SRCREV to point to a different commit in a bbappend file to
#   Or add patches as required

LINUX_VERSION = "3.6"
SRCREV = "04d9378881401e71f83b8b4fea0abd71d33b4052"


require linux-machine-common.inc

# Use the 3.10 defconfigs
MACHINE_KCONFIG_LINUX_VERSION = "3.10"

COMPATIBLE_MACHINE_zynq = "zynq"
COMPATIBLE_MACHINE_microblaze = "microblaze"

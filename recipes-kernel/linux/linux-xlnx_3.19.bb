LINUX_VERSION = "3.19"
KBRANCH ?= "master"
SRCREV ?= "dda52ddca3e375d949a669177d6f5063cdcf713e"

include linux-xlnx.inc


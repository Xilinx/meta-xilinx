MICROBLAZEPATCHES = ""
MICROBLAZEPATCHES:microblaze = "openssl-microblaze.inc"

require ${MICROBLAZEPATCHES}

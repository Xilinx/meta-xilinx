FILESEXTRAPATHS:append:microblaze := ":${THISDIR}/attr"
SRC_URI:append:microblaze = " file://microblaze-symver.patch"

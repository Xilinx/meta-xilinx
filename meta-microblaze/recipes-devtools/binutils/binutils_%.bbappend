MICROBLAZEPATCHES = ""
MICROBLAZEPATCHES:microblaze = "binutils-microblaze.inc"

require ${MICROBLAZEPATCHES}

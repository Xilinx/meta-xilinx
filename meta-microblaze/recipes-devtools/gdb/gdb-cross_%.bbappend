MICROBLAZEPATCHES = ""
MICROBLAZEPATCHES:microblaze = "gdb-microblaze.inc"

require ${MICROBLAZEPATCHES}

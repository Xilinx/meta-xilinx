# GDB does not yet work on Microblaze
DEPENDS:remove:microblaze = "gdb-cross-${TARGET_ARCH}"

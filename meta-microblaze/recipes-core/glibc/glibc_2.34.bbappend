MB_INC_FILE = ""
MB_INC_FILE:microblaze = "microblaze-glibc.inc"

require ${MB_INC_FILE}

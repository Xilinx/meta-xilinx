INSANE_SKIP:${PN}:append:microblaze = " textrel"

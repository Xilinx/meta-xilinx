# GDB does not yet work on Microblaze
GDB:microblaze = ""

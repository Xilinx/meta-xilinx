RDEPENDS:${PN}:remove:microblaze = "gdb gdbserver"


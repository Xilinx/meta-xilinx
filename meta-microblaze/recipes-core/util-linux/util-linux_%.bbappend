FILESEXTRAPATHS:append:microblaze := ":${THISDIR}/util-linux"
SRC_URI:append:microblaze = " file://util-linux-microblaze.patch"

FILESEXTRAPATHS:append:microblaze := ":${THISDIR}/util-linux-2.39"
SRC_URI:append:microblaze = " file://util-linux-microblaze.patch"

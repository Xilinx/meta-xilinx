FILESEXTRAPATHS:append:microblaze := ":${THISDIR}/util-linux-2.40"
SRC_URI:append:microblaze = " file://util-linux-microblaze.patch"

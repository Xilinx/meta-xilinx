MICROBLAZEPATCHES = ""
MICROBLAZEPATCHES:microblaze = "libgloss-microblaze.inc"

require ${MICROBLAZEPATCHES}

MICROBLAZEPATCHES = ""
MICROBLAZEPATCHES:microblaze = "newlib-microblaze.inc"

require ${MICROBLAZEPATCHES}

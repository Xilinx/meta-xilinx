COMPATIBLE_HOST:xilinx-freertos = "${HOST_SYS}"


COMPATIBLE_HOST:xilinx-freertos = "${HOST_SYS}"

DT_INCLUDE:kria:append = "${DT_FILES_PATH}/u-boot-xlnx/include/"

require ${@'base-pdi_sdt.inc' if d.getVar('XILINX_WITH_ESW') == 'sdt' else ''}

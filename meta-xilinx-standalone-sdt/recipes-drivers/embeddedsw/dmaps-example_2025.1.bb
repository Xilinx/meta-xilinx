inherit esw_examples features_check

REQUIRED_MACHINE_FEATURES = "dmaps"

ESW_COMPONENT_SRC = "/XilinxProcessorIPLib/drivers/dmaps/examples/"

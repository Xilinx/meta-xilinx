inherit esw_examples features_check

REQUIRED_MACHINE_FEATURES = "axipmon"

ESW_COMPONENT_SRC = "/XilinxProcessorIPLib/drivers/axipmon/examples/"

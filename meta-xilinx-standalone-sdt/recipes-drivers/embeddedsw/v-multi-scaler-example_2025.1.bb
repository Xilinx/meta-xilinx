inherit esw_examples features_check

REQUIRED_MACHINE_FEATURES = "v-multi-scaler"

ESW_COMPONENT_SRC = "/XilinxProcessorIPLib/drivers/v_multi_scaler/examples/"

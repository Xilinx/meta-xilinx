inherit esw_examples features_check

REQUIRED_MACHINE_FEATURES = "ipipsu"

ESW_COMPONENT_SRC = "/XilinxProcessorIPLib/drivers/ipipsu/examples/"

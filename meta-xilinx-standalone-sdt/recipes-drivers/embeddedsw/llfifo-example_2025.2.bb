inherit esw_examples features_check

REQUIRED_MACHINE_FEATURES = "llfifo"

ESW_COMPONENT_SRC = "/XilinxProcessorIPLib/drivers/llfifo/examples/"

inherit esw_examples features_check

REQUIRED_MACHINE_FEATURES = "usbpsu"

ESW_COMPONENT_SRC = "/XilinxProcessorIPLib/drivers/usbpsu/examples/"

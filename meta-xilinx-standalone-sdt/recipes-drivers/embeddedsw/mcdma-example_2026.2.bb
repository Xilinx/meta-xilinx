inherit esw_examples features_check

REQUIRED_MACHINE_FEATURES = "mcdma"

ESW_COMPONENT_SRC = "/XilinxProcessorIPLib/drivers/mcdma/examples/"

inherit esw_examples features_check

REQUIRED_MACHINE_FEATURES = "clk-wiz"

ESW_COMPONENT_SRC = "/XilinxProcessorIPLib/drivers/clk_wiz/examples/"

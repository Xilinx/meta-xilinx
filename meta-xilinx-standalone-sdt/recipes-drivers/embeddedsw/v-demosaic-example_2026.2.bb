inherit esw_examples features_check

REQUIRED_MACHINE_FEATURES = "v-demosaic"

ESW_COMPONENT_SRC = "/XilinxProcessorIPLib/drivers/v_demosaic/examples/"

inherit esw_examples features_check

REQUIRED_MACHINE_FEATURES = "pciepsu"

ESW_COMPONENT_SRC = "/XilinxProcessorIPLib/drivers/pciepsu/examples/"

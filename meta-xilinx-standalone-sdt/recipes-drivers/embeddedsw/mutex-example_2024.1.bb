inherit esw_examples features_check

REQUIRED_MACHINE_FEATURES = "mutex"

ESW_COMPONENT_SRC = "/XilinxProcessorIPLib/drivers/mutex/examples/"

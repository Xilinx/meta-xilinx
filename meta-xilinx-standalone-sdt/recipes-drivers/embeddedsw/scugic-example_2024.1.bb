inherit esw_examples features_check

REQUIRED_MACHINE_FEATURES = "scugic"

ESW_COMPONENT_SRC = "/XilinxProcessorIPLib/drivers/scugic/examples/"

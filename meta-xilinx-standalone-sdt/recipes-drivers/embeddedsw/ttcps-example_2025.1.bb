inherit esw_examples features_check

REQUIRED_MACHINE_FEATURES = "ttcps"

ESW_COMPONENT_SRC = "/XilinxProcessorIPLib/drivers/ttcps/examples/"

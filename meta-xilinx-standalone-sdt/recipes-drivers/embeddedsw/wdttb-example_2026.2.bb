inherit esw_examples features_check

REQUIRED_MACHINE_FEATURES = "wdttb"

ESW_COMPONENT_SRC = "/XilinxProcessorIPLib/drivers/wdttb/examples/"

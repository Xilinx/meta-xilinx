inherit esw_examples features_check

REQUIRED_MACHINE_FEATURES = "sysmon"

ESW_COMPONENT_SRC = "/XilinxProcessorIPLib/drivers/sysmon/examples/"

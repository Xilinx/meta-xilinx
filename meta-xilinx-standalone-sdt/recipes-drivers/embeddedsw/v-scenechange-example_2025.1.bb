inherit esw_examples features_check

REQUIRED_MACHINE_FEATURES = "v-scenechange"

ESW_COMPONENT_SRC = "/XilinxProcessorIPLib/drivers/v_scenechange/examples/"

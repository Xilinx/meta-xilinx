inherit esw_examples features_check

REQUIRED_MACHINE_FEATURES = "intc"

ESW_COMPONENT_SRC = "/XilinxProcessorIPLib/drivers/intc/examples/"

AIEFAL_BAREMETAL = ""
AIEFAL_BAREMETAL:xilinx-standalone = "aiefal-baremetal.inc"

require ${AIEFAL_BAREMETAL}

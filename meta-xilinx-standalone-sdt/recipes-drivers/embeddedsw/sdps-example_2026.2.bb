inherit esw_examples features_check

REQUIRED_MACHINE_FEATURES = "sdps"

ESW_COMPONENT_SRC = "/XilinxProcessorIPLib/drivers/sdps/examples/"

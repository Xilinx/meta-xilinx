inherit esw_examples features_check

REQUIRED_MACHINE_FEATURES = "xxvethernet"

ESW_COMPONENT_SRC = "/XilinxProcessorIPLib/drivers/xxvethernet/examples/"

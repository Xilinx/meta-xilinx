inherit esw_examples features_check

REQUIRED_MACHINE_FEATURES = "tmrctr"

ESW_COMPONENT_SRC = "/XilinxProcessorIPLib/drivers/tmrctr/examples/"

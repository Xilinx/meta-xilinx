inherit esw_examples features_check

REQUIRED_MACHINE_FEATURES = "vprocss"

ESW_COMPONENT_SRC = "/XilinxProcessorIPLib/drivers/vprocss/examples/"

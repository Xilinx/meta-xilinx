inherit esw_examples features_check

REQUIRED_MACHINE_FEATURES = "i3cpsx"

ESW_COMPONENT_SRC = "/XilinxProcessorIPLib/drivers/i3cpsx/examples/"

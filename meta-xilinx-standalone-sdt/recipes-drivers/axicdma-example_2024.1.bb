inherit esw_examples features_check

REQUIRED_MACHINE_FEATURES = "axicdma"

ESW_COMPONENT_SRC = "/XilinxProcessorIPLib/drivers/axicdma/examples/"

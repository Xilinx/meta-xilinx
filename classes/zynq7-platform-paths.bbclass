# Define the path to the zynq platform init code/headers
PLATFORM_INIT_DIR = "/usr/src/zynq7-platform"
PLATFORM_INIT_STAGE_DIR = "${STAGING_DIR_HOST}${PLATFORM_INIT_DIR}"


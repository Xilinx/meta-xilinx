# Has a dependency on libmali
PACKAGE_ARCH:mali400 = "${SOC_VARIANT_ARCH}"


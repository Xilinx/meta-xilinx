# Has a dependency on libmali
PACKAGE_ARCH_mali400 = "${SOC_VARIANT_ARCH}"

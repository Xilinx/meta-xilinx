RDEPENDS:${PN} += "xkbcomp"

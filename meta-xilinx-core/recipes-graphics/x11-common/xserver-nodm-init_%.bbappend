FILESEXTRAPATHS:append := ":${THISDIR}/${PN}"

COMPATIBLE_MACHINE:versal-2ve-2vm = ".*"

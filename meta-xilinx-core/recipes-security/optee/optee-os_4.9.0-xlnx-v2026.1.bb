require optee-os-amd.inc

BRANCH = "xlnx_rebase_v4.9.0"
SRCREV = "a966fbbdc09c07e34c61de32246b82418aa21552"

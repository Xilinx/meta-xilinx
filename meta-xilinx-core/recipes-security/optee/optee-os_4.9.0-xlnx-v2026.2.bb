require optee-os-amd.inc

BRANCH = "xlnx_rebase_v4.9.0"
SRCREV = "157bdad546ccee2f1e9808939fee87914f63c944"

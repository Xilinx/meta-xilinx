require optee-os-amd.inc

BRANCH = "xlnx_rebase_v4.5.0_update"
SRCREV = "67d5cbba5b31d0c345fe09559fd35ae3ab0cf7b3"

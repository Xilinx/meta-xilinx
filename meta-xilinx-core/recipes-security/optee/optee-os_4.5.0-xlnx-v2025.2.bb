require optee-os-amd.inc

BRANCH = "xlnx_rebase_v4.5.0"
SRCREV = "dfd1bb36573925cdd7fe7132527640d03393ab6f"

require recipes-security/optee/optee-examples.inc
COMPATIBLE_MACHINE:versal-2ve-2vm = ".*"

SRCREV = "5306d2c7c618bb4a91df17a2d5d79ae4701af4a3"

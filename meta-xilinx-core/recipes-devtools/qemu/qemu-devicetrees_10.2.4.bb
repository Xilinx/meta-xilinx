PE = "1"

require qemu-devicetrees.inc

BRANCH ?= "master"
SRCREV ?= "9c64c4a8535f1f9f98aa587f26ee6d3a7c7eff93"

LIC_FILES_CHKSUM = "file://Makefile;beginline=1;endline=28;md5=910f55f350edb281f6a71c45ec27cf2b"

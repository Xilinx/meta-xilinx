
require qemu-devicetrees.inc

BRANCH ?= "master"
SRCREV ?= "b5754fcf322e6474e5b5edf165dc0c954ba58421"



require qemu-devicetrees.inc

BRANCH ?= "master"
SRCREV ?= "247e9edbd9c491d78dd41ee3c85ea38a309c0f67"

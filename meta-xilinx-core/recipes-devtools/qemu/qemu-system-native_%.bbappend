require qemu-system-native-alt.inc

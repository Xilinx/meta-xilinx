PE = "1"

require qemu-devicetrees.inc

BRANCH ?= "xlnx_rel_v2026.1.1"
SRCREV ?= "d55f7059c6d9fc7299c644b398dfda7d2aab1b50"

LIC_FILES_CHKSUM = "file://Makefile;beginline=1;endline=28;md5=910f55f350edb281f6a71c45ec27cf2b"


require qemu-devicetrees.inc

BRANCH ?= "master"
SRCREV ?= "2a44b7c4bd42a13e41cae9269de372862ed1e464"



require qemu-devicetrees.inc

BRANCH ?= "master"
SRCREV ?= "1c45adcde1fc06432c01be250bf668c6477d8459"


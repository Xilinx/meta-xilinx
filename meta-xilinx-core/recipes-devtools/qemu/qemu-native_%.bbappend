require qemu-native-alt.inc


require qemu-devicetrees.inc

BRANCH ?= "xlnx_rel_v2025.1"
SRCREV ?= "8f4830d1a54c2bcbf8b9ee1af2662a0c3d488ed6"


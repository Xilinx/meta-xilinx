
require qemu-devicetrees.inc

BRANCH ?= "master"
SRCREV ?= "b9c88cbfaaa0c8b8be70ea3c74f4cb69fb02a080"


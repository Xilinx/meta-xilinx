
require qemu-devicetrees.inc

BRANCH ?= "xlnx_rel_v2023.2_ksb"
SRCREV ?= "987676c3c781d261279e00c0d21e5d1d0638a756"


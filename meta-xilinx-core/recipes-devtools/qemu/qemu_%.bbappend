# Has a dependency on libmali
PACKAGE_ARCH:mali400 = "${MACHINE_ARCH}"

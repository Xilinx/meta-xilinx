# Older xrt requires a manual dependency on libmetal
DEPENDS:append:versal-ai-core = " libmetal"
DEPENDS:append:versal-ai-edge = " libmetal"

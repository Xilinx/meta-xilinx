# Prevents parse failrues on zynq

COMPATIBLE_MACHINE:zynq = "^$"

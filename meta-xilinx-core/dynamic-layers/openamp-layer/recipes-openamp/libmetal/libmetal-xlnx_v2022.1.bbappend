SKIP_RECIPE[libmetal-xlnx] = "This version is no longer compatible with meta-xilinx."

FILES:libquadmath:append:mingw32 = "\
                         ${bindir}/libquadmath-0.dll \
                        "
FILES:libquadmath-staticdev:append:mingw32 = "\
                      ${libdir}/libquadmath.dll.a \
                     "

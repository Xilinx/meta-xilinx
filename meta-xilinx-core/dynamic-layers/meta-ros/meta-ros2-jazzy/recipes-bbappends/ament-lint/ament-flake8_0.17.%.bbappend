# Copyright (C) 2024 Advanced Micro Devices, Inc.  All rights reserved.

ROS_EXEC_DEPENDS:remove = " \
    python3-flake8-builtins \
    python3-flake8-comprehensions \
    python3-flake8-docstrings \
    python3-flake8-import-order \
    python3-flake8-quotes \
"
# fix symbol_why for v6.18-rc1+ (From OE-Core rev: 8306d2bdcc48718aaa35dfa56b5364d90ea2a1db)
# Need newer kern-tools-native to handle menu-attributes syntax changes.
SRCREV = "f589e1df23251d8319063da0a61c1016b2a0bf85"

require u-boot-xlnx-devicetree.inc
include u-boot-spl-zynq-init.inc

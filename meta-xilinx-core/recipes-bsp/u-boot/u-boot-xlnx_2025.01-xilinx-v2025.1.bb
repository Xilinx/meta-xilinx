
require u-boot-xlnx.inc
require u-boot-spl-zynq-init.inc
require u-boot-xlnx-2025.1.inc
require u-boot-xlnx-arch-2025.1.inc

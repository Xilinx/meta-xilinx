
require u-boot-xlnx.inc
require u-boot-spl-zynq-init.inc
require u-boot-xlnx-2024.2.inc

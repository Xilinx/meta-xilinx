
require u-boot-xlnx.inc
require u-boot-spl-zynq-init.inc
require u-boot-xlnx-2023.2.inc

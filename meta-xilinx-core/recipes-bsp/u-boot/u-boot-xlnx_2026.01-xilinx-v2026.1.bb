require u-boot-xlnx.inc
require u-boot-spl-zynq-init.inc
require u-boot-xlnx-2026.1.inc
require u-boot-xlnx-arch-2026.1.inc
SRCREV = "0897efd45ccad29a3dbab610578c70e3a52b2caa"
BRANCH = "xlnx_rebase_v2.6"
LIC_FILES_CHKSUM = "file://license.rst;md5=1dd070c98a281d18d9eefd938729b031"


include arm-trusted-firmware.inc


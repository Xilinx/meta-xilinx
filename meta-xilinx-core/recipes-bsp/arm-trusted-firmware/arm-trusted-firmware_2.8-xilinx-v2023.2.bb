SRCREV = "6be857cb66300fb21e3f61308e4197911c8ac30d"
BRANCH = "xlnx_rebase_v2.8"
LIC_FILES_CHKSUM = "file://license.rst;md5=1dd070c98a281d18d9eefd938729b031"


include arm-trusted-firmware.inc


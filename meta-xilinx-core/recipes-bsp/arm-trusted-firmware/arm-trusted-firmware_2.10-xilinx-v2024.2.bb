SRCREV = "e9c52930cda49a2f91b74c3e70999197817de022"
BRANCH = "xlnx_rebase_v2.10"
LIC_FILES_CHKSUM = "file://license.rst;md5=1dd070c98a281d18d9eefd938729b031"


include arm-trusted-firmware.inc


SRCREV = "67ca59c67f542322554d78820bf9ddaa736d6a84"
BRANCH = "xlnx_rebase_v2.6"
LIC_FILES_CHKSUM = "file://license.rst;md5=1dd070c98a281d18d9eefd938729b031"


include arm-trusted-firmware.inc


ATF_VERSION = "2.6"
SRCREV = "b9d9554f2357e6190710df41df706c33550170ef"
BRANCH = "xlnx_rebase_v2.6"
LIC_FILES_CHKSUM = "file://license.rst;md5=1dd070c98a281d18d9eefd938729b031"


include arm-trusted-firmware.inc


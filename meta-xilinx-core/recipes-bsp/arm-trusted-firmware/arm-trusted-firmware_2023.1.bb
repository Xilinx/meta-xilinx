ATF_VERSION = "2.8"
SRCREV = "d9c00f0abf7cafad8df7908492c2b94db5d93641"
BRANCH = "xlnx_rebase_v2.8"
LIC_FILES_CHKSUM = "file://license.rst;md5=1dd070c98a281d18d9eefd938729b031"


include arm-trusted-firmware.inc


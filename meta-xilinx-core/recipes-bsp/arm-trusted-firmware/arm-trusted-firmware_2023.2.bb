ATF_VERSION = "2.8"
SRCREV = "ed3c4f0532b7d10ffd16a9c63d513c23dbfa28eb"
BRANCH = "xlnx_rebase_v2.8"
LIC_FILES_CHKSUM = "file://license.rst;md5=1dd070c98a281d18d9eefd938729b031"


include arm-trusted-firmware.inc


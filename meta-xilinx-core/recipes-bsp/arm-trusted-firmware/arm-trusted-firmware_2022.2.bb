ATF_VERSION = "2.6"
SRCREV = "c7e8c327df53e97e1ad5e52e3b8ae2ba57f6565d"
BRANCH = "xlnx_rebase_v2.6"
LIC_FILES_CHKSUM = "file://license.rst;md5=1dd070c98a281d18d9eefd938729b031"


include arm-trusted-firmware.inc


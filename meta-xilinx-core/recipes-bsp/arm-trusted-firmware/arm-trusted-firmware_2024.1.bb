ATF_VERSION = "2.8"
SRCREV = "1ce681f023ba57a16c72538ee124a106cc4b3988"
BRANCH = "xlnx_rebase_v2.8"
LIC_FILES_CHKSUM = "file://license.rst;md5=1dd070c98a281d18d9eefd938729b031"


include arm-trusted-firmware.inc


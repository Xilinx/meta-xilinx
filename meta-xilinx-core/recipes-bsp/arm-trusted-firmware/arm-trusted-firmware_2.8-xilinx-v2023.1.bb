SRCREV = "c9b71dc96f3f18ca94cad590612aae3224c8c84d"
BRANCH = "xlnx_rebase_v2.8"
LIC_FILES_CHKSUM = "file://license.rst;md5=1dd070c98a281d18d9eefd938729b031"


include arm-trusted-firmware.inc


# Minimum board memory required for each type
QB_MEM:microblaze = "-m 2G"
QB_MEM:zynq       = "-m 1G"
QB_MEM:zynqmp     = "-m 4G"
QB_MEM:versal     = "-m 16G"
QB_MEM:versal-net = "-m 16G"

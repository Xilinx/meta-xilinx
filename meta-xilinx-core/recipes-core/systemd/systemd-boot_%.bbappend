FILESEXTRAPATHS:prepend := "${THISDIR}/systemd-boot:"

SRC_URI += "file://0001-boot-Re-enable-console-cursor-after-leaving-boot-men.patch"

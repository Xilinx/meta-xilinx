# mesa-demos does not work with libmali-xlnx
X11GLTOOLS:remove:mali400 = "mesa-demos"

# Links to mesa / libmali-xlnx, so it becomes MACHINE_ARCH specific
PACKAGE_ARCH = "${MACHINE_ARCH}"

# Links to mesa / libmali-xlnx, so it becomes MACHINE_ARCH specific
PACKAGE_ARCH = "${MACHINE_ARCH}"
# Note: qtbase has a dependency on opengl, which triggers dependencies on it's users

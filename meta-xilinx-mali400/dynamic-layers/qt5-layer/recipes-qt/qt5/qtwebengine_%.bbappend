PACKAGECONFIG:append = " ffmpeg opus"

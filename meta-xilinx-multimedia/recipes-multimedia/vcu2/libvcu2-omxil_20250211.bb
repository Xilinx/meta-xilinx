LIC_FILES_CHKSUM = "file://LICENSE.md;md5=ac7c6b649ce8caa4f4c517aaa77c8b17"

BRANCH ?= "xlnx_rel_v2025.1"
SRCREV = "491a82ee4cace66c06a20fcf3fdbff185b7713f6"

require libvcu2-omxil.inc

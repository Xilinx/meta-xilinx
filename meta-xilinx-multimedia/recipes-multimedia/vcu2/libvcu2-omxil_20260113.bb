LIC_FILES_CHKSUM = "file://LICENSE.md;md5=624e7970a65c3e70b309116d8fb6c3d7"

BRANCH ?= "master"
SRCREV = "ec333ab622d2adb0264c2a7ebb07108173fbb61c"

require libvcu2-omxil.inc

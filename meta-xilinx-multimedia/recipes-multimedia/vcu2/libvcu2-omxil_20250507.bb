LIC_FILES_CHKSUM = "file://LICENSE.md;md5=ac7c6b649ce8caa4f4c517aaa77c8b17"

BRANCH ?= "master"
SRCREV = "c4ea06edb9ddf77d4ea4b29bb358bfb9fb29b34b"

require libvcu2-omxil.inc

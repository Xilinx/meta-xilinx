LIC_FILES_CHKSUM = "file://LICENSE.md;md5=ac7c6b649ce8caa4f4c517aaa77c8b17"

BRANCH ?= "master"
SRCREV = "c36569c754aeb8b3f60d3b3a5d333eb27efa5b29"

require libvcu2-omxil.inc

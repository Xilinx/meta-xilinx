LIC_FILES_CHKSUM = "file://LICENSE.md;md5=624e7970a65c3e70b309116d8fb6c3d7"

BRANCH ?= "master"
SRCREV = "5e5b0ff52f0795fa95f5ad961037a133bd0ff946"

require libvcu2-omxil.inc

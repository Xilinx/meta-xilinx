require gstreamer-xilinx-1.22.%.inc

S = "${UNPACKDIR}/git/subprojects/gst-plugins-ugly"

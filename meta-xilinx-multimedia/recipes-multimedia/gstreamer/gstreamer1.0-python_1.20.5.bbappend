require gstreamer-xilinx-1.20.5.inc

S = "${WORKDIR}/git/subprojects/gst-python"


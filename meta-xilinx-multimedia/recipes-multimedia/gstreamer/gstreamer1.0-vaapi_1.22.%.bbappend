require gstreamer-xilinx-1.22.%.inc

S = "${UNPACKDIR}/git/subprojects/gstreamer-vaapi"

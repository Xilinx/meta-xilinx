require gstreamer-xilinx-1.20.5.inc

S = "${UNPACKDIR}/git/subprojects/gst-plugins-ugly"

require gstreamer-xilinx-1.22.11.inc

S = "${WORKDIR}/git/subprojects/gst-plugins-ugly"

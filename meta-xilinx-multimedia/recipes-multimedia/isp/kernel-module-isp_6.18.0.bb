SRCREV = "b2cea0527879ce9977a887134422a7c33b3d586a"
SRC_BRANCH = "master"
SRCREV = "b2cea0527879ce9977a887134422a7c33b3d586a"

include kernel-module-isp.inc

PV .= "+git"

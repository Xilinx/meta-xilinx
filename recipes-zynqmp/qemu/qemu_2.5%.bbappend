
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += " \
		file://4054bfa9e7986c9b7d2bf70f9e10af9647e376fc.patch \
		file://8a83ffc2dafad3499b87a736b17ab1b203fdb00b.patch \
		file://978364f12adebb4b8d90fdeb71242cb3c1405740.patch \
		"


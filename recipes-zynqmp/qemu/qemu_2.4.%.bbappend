
FILESEXTRAPATHS_append := "${THISDIR}/files:"
SRC_URI_append += " \
		file://arm-xlnx-zynqmp-Fix-up-GIC-region-size.patch \
		"


inherit esw_examples

ESW_COMPONENT_SRC = "/lib/sw_apps/hello_world/src"

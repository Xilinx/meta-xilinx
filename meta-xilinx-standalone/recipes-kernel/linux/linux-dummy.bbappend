COMPATIBLE_OS_xilinx-standalone = "${TARGET_OS}"

inherit esw

ESW_COMPONENT_SRC = "/lib/sw_services/xilffs/src/"
ESW_COMPONENT_NAME = "libxilffs.a"

DEPENDS += " xilstandalone libxil"

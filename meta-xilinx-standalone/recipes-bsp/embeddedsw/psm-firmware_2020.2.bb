require psm-firmware.inc

DEFAULT_PREFERENCE = "-1"

require ${@'imgrcry-meta-xilinx-standalone.inc' if d.getVar('XILINX_WITH_ESW') == 'sdt' else ''}

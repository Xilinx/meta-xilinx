require ${@'rpu1-hello-world-meta-xilinx-standalone.inc' if d.getVar('XILINX_WITH_ESW') else ''}

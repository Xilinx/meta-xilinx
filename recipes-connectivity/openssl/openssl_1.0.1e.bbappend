
FILESEXTRAPATHS := "${THISDIR}/files"
SRC_URI_append += "file://Add-MicroBlaze-Support.patch"

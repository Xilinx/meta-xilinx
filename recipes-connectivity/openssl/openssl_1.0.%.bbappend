
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI_append += "file://Add-MicroBlaze-Support.patch"

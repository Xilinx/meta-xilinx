include arm-trusted-firmware.inc

XILINX_RELEASE_VERSION = "v2017.1"
SRCREV ?= "7d1a6732c9ae113999aeabcb9912369760d05c13"

PV = "1.3-xilinx-${XILINX_RELEASE_VERSION}+git${SRCPV}"


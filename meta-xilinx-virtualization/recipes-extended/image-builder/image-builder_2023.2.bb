BRANCH = "xlnx_rel_v2023.2"
SRCREV = "297a48f8635713a14469a92d49f7e292554dedc9"

include image-builder.inc

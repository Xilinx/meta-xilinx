BRANCH = "xlnx_rel_v2023.1"
SRCREV = "37ba04b63cb2c01d8e683f31a9eb3878f1e80305"

include image-builder.inc

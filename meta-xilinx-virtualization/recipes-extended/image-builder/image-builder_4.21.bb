BRANCH = "xlnx_rebase_4.21"
SRCREV = "8bef811af9f1b20827699c7cf9974e39df57bdd1"

PE = "1"

include image-builder.inc

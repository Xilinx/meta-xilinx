BRANCH = "xlnx_rel_v2025.2"
SRCREV = "67f859ebeea11285eff1cd88873e56884e1e9053"

include image-builder.inc

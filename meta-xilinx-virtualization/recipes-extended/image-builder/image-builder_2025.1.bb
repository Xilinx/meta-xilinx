BRANCH = "xlnx_rel_v2025.1"
SRCREV = "75e3631fb8263bf85dc4e7444933d24daf7970a5"

include image-builder.inc

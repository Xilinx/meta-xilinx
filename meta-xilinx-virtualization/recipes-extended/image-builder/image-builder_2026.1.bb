BRANCH = "xlnx_rel_v2026.1"
SRCREV = "8bef811af9f1b20827699c7cf9974e39df57bdd1"

include image-builder.inc

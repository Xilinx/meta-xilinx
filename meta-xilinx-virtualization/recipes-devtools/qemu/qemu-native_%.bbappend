require qemu-tpm.inc

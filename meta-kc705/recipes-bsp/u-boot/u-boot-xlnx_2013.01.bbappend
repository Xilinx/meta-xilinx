
FILESEXTRAPATHS_append_kc705-trd := "${THISDIR}/files:"
SRC_URI_append_kc705-trd = " \
		file://config.mk \
		file://xparameters.h \
		"

COMMON_INSTALL:append:versal-net = " dpdk libmcdi"



FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://MicroBlaze-fix-up-pt-vfork-symbol-definitions.patch"


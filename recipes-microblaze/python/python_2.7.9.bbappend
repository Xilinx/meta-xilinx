
DEPENDS_append_microblaze += "libffi"
CONFIGUREOPTS_append_microblaze += "--with-system-ffi"


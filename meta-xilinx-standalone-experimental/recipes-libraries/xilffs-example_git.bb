inherit esw_examples features_check

ESW_COMPONENT_SRC = "/lib/sw_services/xilffs/examples/"

DEPENDS += "xilffs"

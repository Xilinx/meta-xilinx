require openamp-fw.inc

PROVIDES:append:armv7r = " openamp-fw-mat-muld "

OPENAMP_FW_SRC_NAME = "matrix_multiplyd.out"
OPENAMP_FW_NAME = "image_matrix_multiply"

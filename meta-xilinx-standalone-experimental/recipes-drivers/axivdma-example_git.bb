inherit esw_examples features_check

REQUIRED_DISTRO_FEATURES = "axivdma"

ESW_COMPONENT_SRC = "/XilinxProcessorIPLib/drivers/axivdma/examples/"

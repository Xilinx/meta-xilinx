inherit esw_examples features_check

REQUIRED_DISTRO_FEATURES = "uartlite"

ESW_COMPONENT_SRC = "/XilinxProcessorIPLib/drivers/uartlite/examples/"

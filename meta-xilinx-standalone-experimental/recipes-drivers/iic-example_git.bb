inherit esw_examples features_check
  
REQUIRED_DISTRO_FEATURES = "iic"

ESW_COMPONENT_SRC = "/XilinxProcessorIPLib/drivers/iic/examples/"

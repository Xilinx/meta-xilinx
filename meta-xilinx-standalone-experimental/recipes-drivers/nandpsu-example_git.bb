inherit esw_examples features_check

REQUIRED_DISTRO_FEATURES = "nandpsu"

ESW_COMPONENT_SRC = "/XilinxProcessorIPLib/drivers/nandpsu/examples/"

inherit esw_examples features_check

REQUIRED_DISTRO_FEATURES = "spips"

ESW_COMPONENT_SRC = "/XilinxProcessorIPLib/drivers/spips/examples/"

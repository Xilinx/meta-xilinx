inherit esw_examples features_check

REQUIRED_DISTRO_FEATURES = "rtcpsu"

ESW_COMPONENT_SRC = "/XilinxProcessorIPLib/drivers/rtcpsu/examples/"

inherit esw_examples features_check

REQUIRED_DISTRO_FEATURES = "iicps"

ESW_COMPONENT_SRC = "/XilinxProcessorIPLib/drivers/iicps/examples/"

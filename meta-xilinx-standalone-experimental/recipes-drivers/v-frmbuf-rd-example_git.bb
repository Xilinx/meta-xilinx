inherit esw_examples distro_features_check

REQUIRED_DISTRO_FEATURES = "v-frmbuf-rd"

ESW_COMPONENT_SRC = "/XilinxProcessorIPLib/drivers/v_frmbuf_rd/examples/"

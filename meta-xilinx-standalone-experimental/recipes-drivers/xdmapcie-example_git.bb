inherit esw_examples distro_features_check

REQUIRED_DISTRO_FEATURES = "xdmapcie"

ESW_COMPONENT_SRC = "/XilinxProcessorIPLib/drivers/xdmapcie/examples/"

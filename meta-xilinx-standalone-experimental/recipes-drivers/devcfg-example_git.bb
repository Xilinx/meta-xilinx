inherit esw_examples features_check

REQUIRED_DISTRO_FEATURES = "devcfg"

ESW_COMPONENT_SRC = "/XilinxProcessorIPLib/drivers/devcfg/examples/"

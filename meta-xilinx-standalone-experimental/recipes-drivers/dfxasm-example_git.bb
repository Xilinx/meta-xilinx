inherit esw_examples features_check

REQUIRED_DISTRO_FEATURES = "dfxasm"

ESW_COMPONENT_SRC = "/XilinxProcessorIPLib/drivers/dfxasm/examples/"

inherit esw_examples features_check

REQUIRED_DISTRO_FEATURES = "axiethernet"

ESW_COMPONENT_SRC = "/XilinxProcessorIPLib/drivers/axiethernet/examples/"

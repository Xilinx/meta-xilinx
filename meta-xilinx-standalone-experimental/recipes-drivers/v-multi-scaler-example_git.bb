inherit esw_examples distro_features_check

REQUIRED_DISTRO_FEATURES = "v-multi-scaler"

ESW_COMPONENT_SRC = "/XilinxProcessorIPLib/drivers/v_multi_scaler/examples/"

inherit esw_examples features_check

REQUIRED_DISTRO_FEATURES = "emacps"

ESW_COMPONENT_SRC = "/XilinxProcessorIPLib/drivers/emacps/examples/"

inherit esw_examples distro_features_check

REQUIRED_DISTRO_FEATURES = "v-mix"

ESW_COMPONENT_SRC = "/XilinxProcessorIPLib/drivers/v_mix/examples/"

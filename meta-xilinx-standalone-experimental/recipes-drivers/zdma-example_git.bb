inherit esw_examples features_check

REQUIRED_DISTRO_FEATURES = "zdma"

ESW_COMPONENT_SRC = "/XilinxProcessorIPLib/drivers/zdma/examples/"

inherit esw_examples distro_features_check

REQUIRED_DISTRO_FEATURES = "v-frmbuf-wr"

ESW_COMPONENT_SRC = "/XilinxProcessorIPLib/drivers/v_frmbuf_wr/examples/"

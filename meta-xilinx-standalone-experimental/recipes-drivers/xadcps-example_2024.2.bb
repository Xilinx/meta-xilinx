inherit esw_examples features_check

REQUIRED_MACHINE_FEATURES = "xadcps"

ESW_COMPONENT_SRC = "/XilinxProcessorIPLib/drivers/xadcps/examples/"

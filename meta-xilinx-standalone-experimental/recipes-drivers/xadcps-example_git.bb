inherit esw_examples features_check

REQUIRED_DISTRO_FEATURES = "xadcps"

ESW_COMPONENT_SRC = "/XilinxProcessorIPLib/drivers/xadcps/examples/"

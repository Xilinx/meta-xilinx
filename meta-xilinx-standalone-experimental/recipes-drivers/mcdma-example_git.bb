inherit esw_examples features_check

REQUIRED_DISTRO_FEATURES = "mcdma"

ESW_COMPONENT_SRC = "/XilinxProcessorIPLib/drivers/mcdma/examples/"

inherit esw_examples features_check

REQUIRED_DISTRO_FEATURES = "trafgen"

ESW_COMPONENT_SRC = "/XilinxProcessorIPLib/drivers/trafgen/examples/"

inherit esw_examples features_check

REQUIRED_DISTRO_FEATURES = "gpiops"

ESW_COMPONENT_SRC = "/XilinxProcessorIPLib/drivers/gpiops/examples/"

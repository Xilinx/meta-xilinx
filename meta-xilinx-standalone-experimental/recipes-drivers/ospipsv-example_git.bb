inherit esw_examples features_check

REQUIRED_DISTRO_FEATURES = "ospipsv"

ESW_COMPONENT_SRC = "/XilinxProcessorIPLib/drivers/ospipsv/examples/"

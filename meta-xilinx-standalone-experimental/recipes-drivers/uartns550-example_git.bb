inherit esw_examples features_check
  
REQUIRED_DISTRO_FEATURES = "uartns550"

ESW_COMPONENT_SRC = "/XilinxProcessorIPLib/drivers/uartns550/examples/"


inherit esw_examples features_check

REQUIRED_DISTRO_FEATURES = "emaclite"

ESW_COMPONENT_SRC = "/XilinxProcessorIPLib/drivers/emaclite/examples/"

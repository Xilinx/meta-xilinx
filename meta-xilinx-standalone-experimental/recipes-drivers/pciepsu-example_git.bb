inherit esw_examples distro_features_check

REQUIRED_DISTRO_FEATURES = "pciepsu"

ESW_COMPONENT_SRC = "/XilinxProcessorIPLib/drivers/pciepsu/examples/"

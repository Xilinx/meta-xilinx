inherit esw_examples features_check

REQUIRED_DISTRO_FEATURES = "gpio"

ESW_COMPONENT_SRC = "/XilinxProcessorIPLib/drivers/gpio/examples/"

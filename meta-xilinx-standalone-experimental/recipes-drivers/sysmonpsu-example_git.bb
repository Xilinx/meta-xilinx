inherit esw_examples features_check

REQUIRED_DISTRO_FEATURES = "sysmonpsu"

ESW_COMPONENT_SRC = "/XilinxProcessorIPLib/drivers/sysmonpsu/examples/"

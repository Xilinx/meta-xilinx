inherit esw_examples features_check

REQUIRED_DISTRO_FEATURES = "can"

ESW_COMPONENT_SRC = "/XilinxProcessorIPLib/drivers/can/examples/"

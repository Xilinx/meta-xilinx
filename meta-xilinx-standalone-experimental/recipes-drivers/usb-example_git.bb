inherit esw_examples features_check

REQUIRED_DISTRO_FEATURES = "usb"

ESW_COMPONENT_SRC = "/XilinxProcessorIPLib/drivers/usb/examples/"

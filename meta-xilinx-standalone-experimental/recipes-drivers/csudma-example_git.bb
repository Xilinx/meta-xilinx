inherit esw_examples features_check

REQUIRED_DISTRO_FEATURES = "csudma"

ESW_COMPONENT_SRC = "/XilinxProcessorIPLib/drivers/csudma/examples/"

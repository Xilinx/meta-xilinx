inherit esw_examples features_check

REQUIRED_DISTRO_FEATURES = "canps"

ESW_COMPONENT_SRC = "/XilinxProcessorIPLib/drivers/canps/examples/"

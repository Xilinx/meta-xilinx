inherit esw_examples features_check

REQUIRED_DISTRO_FEATURES = "tmrctr"

ESW_COMPONENT_SRC = "/XilinxProcessorIPLib/drivers/tmrctr/examples/"

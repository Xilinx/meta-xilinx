inherit esw_examples features_check

REQUIRED_DISTRO_FEATURES = "mbox"

ESW_COMPONENT_SRC = "/XilinxProcessorIPLib/drivers/mbox/examples/"

inherit esw_examples features_check
  
REQUIRED_DISTRO_FEATURES = "uartpsv"

ESW_COMPONENT_SRC = "/XilinxProcessorIPLib/drivers/uartpsv/examples/"


inherit esw_examples features_check

REQUIRED_DISTRO_FEATURES = "uartps"

ESW_COMPONENT_SRC = "/XilinxProcessorIPLib/drivers/uartps/examples/"

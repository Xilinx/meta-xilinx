inherit esw_examples features_check

REQUIRED_DISTRO_FEATURES = "qspipsu"

ESW_COMPONENT_SRC = "/XilinxProcessorIPLib/drivers/qspipsu/examples/"

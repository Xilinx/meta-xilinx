inherit esw_examples distro_features_check

REQUIRED_DISTRO_FEATURES = "v-gamma-lut"

ESW_COMPONENT_SRC = "/XilinxProcessorIPLib/drivers/v_gamma_lut/examples/"

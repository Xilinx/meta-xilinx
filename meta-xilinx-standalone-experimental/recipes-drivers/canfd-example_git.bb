inherit esw_examples features_check

REQUIRED_DISTRO_FEATURES = "canfd"

ESW_COMPONENT_SRC = "/XilinxProcessorIPLib/drivers/canfd/examples/"

inherit esw_examples features_check

REQUIRED_DISTRO_FEATURES = "sdps"

ESW_COMPONENT_SRC = "/XilinxProcessorIPLib/drivers/sdps/examples/"

inherit esw_examples features_check

REQUIRED_DISTRO_FEATURES = "ttcps"

ESW_COMPONENT_SRC = "/XilinxProcessorIPLib/drivers/ttcps/examples/"

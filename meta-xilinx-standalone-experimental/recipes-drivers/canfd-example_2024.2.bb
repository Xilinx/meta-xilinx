inherit esw_examples features_check

REQUIRED_MACHINE_FEATURES = "canfd"

ESW_COMPONENT_SRC = "/XilinxProcessorIPLib/drivers/canfd/examples/"

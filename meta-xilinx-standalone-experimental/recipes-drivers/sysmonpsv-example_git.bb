inherit esw_examples distro_features_check

REQUIRED_DISTRO_FEATURES = "sysmonpsv"

ESW_COMPONENT_SRC = "/XilinxProcessorIPLib/drivers/sysmonpsv/examples/"

inherit esw_examples features_check

REQUIRED_DISTRO_FEATURES = "resetps"

ESW_COMPONENT_SRC = "/XilinxProcessorIPLib/drivers/resetps/examples/"

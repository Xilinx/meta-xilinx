inherit esw_examples features_check

REQUIRED_DISTRO_FEATURES = "vprocss"

ESW_COMPONENT_SRC = "/XilinxProcessorIPLib/drivers/vprocss/examples/"

inherit esw_examples features_check

REQUIRED_DISTRO_FEATURES = "axidma"

ESW_COMPONENT_SRC = "/XilinxProcessorIPLib/drivers/axidma/examples/"

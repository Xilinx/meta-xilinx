inherit esw_examples features_check

REQUIRED_DISTRO_FEATURES = "bram"

ESW_COMPONENT_SRC = "/XilinxProcessorIPLib/drivers/bram/examples/"

inherit esw_examples features_check

REQUIRED_DISTRO_FEATURES = "qspips"

ESW_COMPONENT_SRC = "/XilinxProcessorIPLib/drivers/qspips/examples/"

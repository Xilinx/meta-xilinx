inherit esw_examples features_check

REQUIRED_DISTRO_FEATURES = "wdttb"

ESW_COMPONENT_SRC = "/XilinxProcessorIPLib/drivers/wdttb/examples/"

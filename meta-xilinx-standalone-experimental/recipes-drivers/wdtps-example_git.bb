inherit esw_examples features_check

REQUIRED_DISTRO_FEATURES = "wdtps"

ESW_COMPONENT_SRC = "/XilinxProcessorIPLib/drivers/wdtps/examples/"

FILESEXTRAPATHS:prepend:ultra96 := "${THISDIR}/files:"

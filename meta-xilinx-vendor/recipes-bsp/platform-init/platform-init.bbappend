FILESEXTRAPATHS:prepend := "${THISDIR}/platform-init:"

COMPATIBLE_MACHINE:picozed-zynq7 = "picozed-zynq7"


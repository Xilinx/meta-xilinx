require qemu-devicetrees.inc

XILINX_RELEASE_VERSION = "v2018.3"

BRANCH ?= "master"
SRCREV ?= "181fb682575057b8f572a5e0d38e0b5bb78c845c"

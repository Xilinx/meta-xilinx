require qemu-xilinx.inc

XILINX_QEMU_VERSION ?= "v2.11.1"
BRANCH ?= "branch/xilinx-v2019.2"
SRCREV ?= "6617fbc8be3525ca524f7d4ef7fc7b14c5b0c822"

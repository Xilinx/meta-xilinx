require qemu-devicetrees.inc

BRANCH ?= "branch/xilinx-v2021.1"
SRCREV ?= "920dab6cdcc16f08daf885cede3593554ddcaef2"

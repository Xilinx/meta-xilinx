require qemu-devicetrees.inc

BRANCH ?= "branch/xilinx-v2020.1"
SRCREV ?= "4978ef3833f2a6a3c62075759605c683d75f6276"

require qemu-devicetrees.inc

BRANCH ?= "branch/xilinx-v2020.3"
SRCREV ?= "cd033c4e08cecc378d53ff14e001fb346df74df5"

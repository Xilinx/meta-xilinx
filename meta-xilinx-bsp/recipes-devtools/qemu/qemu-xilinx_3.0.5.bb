require qemu-xilinx.inc

XILINX_RELEASE_VERSION = "versal"
XILINX_QEMU_VERSION ?= "v2.7.0"
BRANCH ?= "xilinx/versal"
SRCREV ?= "00e076c2dceb5ddda024f716ec98ac9659ce6b74"

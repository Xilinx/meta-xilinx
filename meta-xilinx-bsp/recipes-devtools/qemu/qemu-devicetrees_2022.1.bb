
require qemu-devicetrees.inc

BRANCH ?= "master"
SRCREV ?= "768c7ccd368b9fa64bd8e202630af1d00ecfed04"

require qemu-devicetrees.inc

BRANCH ?= "master"
SRCREV ?= "c886b56a181280540f9cad928de3b4fa48c6af86"

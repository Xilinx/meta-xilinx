require qemu-xilinx.inc

XILINX_RELEASE_VERSION = "v2017.3"
XILINX_QEMU_VERSION = "v2.8.1"
SRCREV ?= "8f8c89b18f6e4523099e41d81769fc534064b8de"

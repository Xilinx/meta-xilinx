require qemu-devicetrees.inc

BRANCH ?= "master"
SRCREV = "4f613eee54f47ab32cc1abb651007b850f6640b4"

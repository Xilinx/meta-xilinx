require qemu-xilinx.inc

XILINX_RELEASE_VERSION = "v2018.3"
XILINX_QEMU_VERSION ?= "v2.11.0"
BRANCH ?= "master"
SRCREV ?= "f5fb2a88ffe61ccb049715cb11b34e9cb216fd5c"

require qemu-devicetrees.inc

XILINX_RELEASE_VERSION = "v2019.1"

BRANCH ?= "master"
SRCREV ?= "d34338583367d93ee2af833f3397b6c69deb00d7"

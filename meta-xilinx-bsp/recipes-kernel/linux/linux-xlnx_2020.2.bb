LINUX_VERSION = "5.4"
SRCREV ?= "cd8a119336cb83f35cf491016ed152e732ddfe6f"

include linux-xlnx.inc


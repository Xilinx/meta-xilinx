LINUX_VERSION = "4.19"
KBRANCH ?= "xlnx_rebase_v4.19"
SRCREV ?= "b983d5fd71d4feaf494cdbe0593ecc29ed471cb8"

include linux-xlnx.inc


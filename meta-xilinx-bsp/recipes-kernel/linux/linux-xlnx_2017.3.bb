LINUX_VERSION = "4.9"
XILINX_RELEASE_VERSION = "v2017.3"
SRCREV ?= "f1b1e077d641fc83b54c1b8f168cbb58044fbd4e"

include linux-xlnx.inc


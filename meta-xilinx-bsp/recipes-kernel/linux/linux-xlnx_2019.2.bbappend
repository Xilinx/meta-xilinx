FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append_a2197-zynqmp = " file://0001-mux-cache-disable.patch"
SRC_URI_append_vck-sc-zynqmp = " file://0001-mux-cache-disable.patch"

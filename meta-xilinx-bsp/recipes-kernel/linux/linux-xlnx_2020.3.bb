LINUX_VERSION = "5.4"
SRCREV ?= "49bdb4e70d2001f3a5bf0bf5e990cca4a85210f4"

include linux-xlnx.inc


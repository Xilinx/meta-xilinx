LINUX_VERSION = "4.19"
XILINX_RELEASE_VERSION = "v2019.1"
KBRANCH ?= "xlnx_rebase_v4.19"
SRCREV ?= "c722e33408d85922e27160b75d4e2f78990f7064"

include linux-xlnx.inc


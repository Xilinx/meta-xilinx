require u-boot-common_2018.01.inc
PV = "2018.01"

RDEPENDS_${PN} += "dtc"


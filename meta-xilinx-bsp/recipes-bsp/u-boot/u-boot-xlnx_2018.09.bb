UBOOT_VERSION = "v2018.09"
XILINX_RELEASE_VERSION = "versal"

UBRANCH = "xilinx/versal"
SRCREV ?= "5cf12995c1ffff59c5280520c687739de6694c06"

include u-boot-xlnx.inc

LICENSE = "GPLv2+"
LIC_FILES_CHKSUM = "file://README;beginline=1;endline=6;md5=37495cdcff8cd78890dc65d37099bc38"


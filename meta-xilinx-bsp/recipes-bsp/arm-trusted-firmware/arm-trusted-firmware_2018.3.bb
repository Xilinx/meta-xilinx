include arm-trusted-firmware.inc
ATF_VERSION = "1.4"
XILINX_RELEASE_VERSION = "v2018.3"
SRCREV ??= "93a69a5a3bc318027da4af5911124537f4907642"
BRANCH ??= "master"

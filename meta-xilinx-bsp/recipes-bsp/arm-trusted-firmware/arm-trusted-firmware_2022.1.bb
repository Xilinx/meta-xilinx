ATF_VERSION = "2.6"
SRCREV = "a23a5545bc16b9d86206e019448e17d351189e4a"
BRANCH = "xlnx_rebase_v2.6"
LIC_FILES_CHKSUM = "file://license.rst;md5=1dd070c98a281d18d9eefd938729b031"


include arm-trusted-firmware.inc


ATF_VERSION = "2.0"
BRANCH ?= "master"
SRCREV ?= "80d1c79007fda42d4cc0be31b185a1da5799cd4d"

include arm-trusted-firmware.inc


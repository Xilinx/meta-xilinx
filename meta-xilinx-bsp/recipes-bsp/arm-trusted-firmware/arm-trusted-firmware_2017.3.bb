ATF_VERSION = "1.3"
XILINX_RELEASE_VERSION = "v2017.3"
SRCREV ?= "f9b244beaa7ac6a670b192192b6e92e5fd6044dc"

include arm-trusted-firmware.inc

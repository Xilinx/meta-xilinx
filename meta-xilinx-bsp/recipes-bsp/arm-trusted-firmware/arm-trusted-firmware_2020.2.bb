ATF_VERSION = "2.0"
BRANCH ?= "master-rel-2020.2.2-som"
SRCREV ?= "6ea45ca9bca82e4df810bb3c07d675a0556e6f73"

include arm-trusted-firmware.inc


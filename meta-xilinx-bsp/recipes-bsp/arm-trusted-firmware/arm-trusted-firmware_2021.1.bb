ATF_VERSION = "2.0"
SRCREV = "851523ea2dd34b71be94870cca82c07f776a6a65"
BRANCH = "xlnx_rebase_v2.4"
LIC_FILES_CHKSUM = "file://license.rst;md5=1dd070c98a281d18d9eefd938729b031"


include arm-trusted-firmware.inc


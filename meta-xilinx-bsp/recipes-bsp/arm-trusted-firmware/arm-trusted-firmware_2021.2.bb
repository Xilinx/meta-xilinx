ATF_VERSION = "2.4"
SRCREV = "9bcc75c7f08476b821a8cd94f2c5651beefae114"
BRANCH = "xlnx_rebase_v2.4"
LIC_FILES_CHKSUM = "file://license.rst;md5=1dd070c98a281d18d9eefd938729b031"


include arm-trusted-firmware.inc

